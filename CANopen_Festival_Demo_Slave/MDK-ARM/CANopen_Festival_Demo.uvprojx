# Keil uVision project CANopen_Festival_Demo.uvprojx, settings and files
target CANopen_Festival_Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: CANopen_Festival_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Festival_Middlewares/lib/Inc;../Festival_Middlewares/lib/Inc/device_config;../Festival_Middlewares/Driver/Inc;../Festival_Middlewares/SensorSlaveNode;../Driver_SHT
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Festival_Middlewares/lib/src
    ../Festival_Middlewares/lib/Src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
  group Festival_Middlewares/lib/Inc
    ../Festival_Middlewares/lib/Inc/: can.h can_driver.h data.h dcf.h def.h emcy.h lifegrd.h lss.h nmtMaster.h nmtSlave.h objacces.h objdictdef.h pdo.h sdo.h states.h sync.h sysdep.h timer.h timers_driver.h
  group Festival_Middlewares/lib/Inc/device_config
    ../Festival_Middlewares/lib/Inc/device_config/: applicfg.h canfestival.h timerscfg.h
  group Festival_Middlewares/Driver/Src
    ../Festival_Middlewares/Driver/Src/: hardwaresdrv.c
  group Festival_Middlewares/SensorSlaveNode
    ../Festival_Middlewares/SensorSlaveNode/: SlaveNode_Sensor.c SlaveNode_Sensor.h
  group Driver_SHT
    ../Driver_SHT/: sht_config.h sht_drv.c mimiciic.c mimiciic.h
software components: CMSIS:CORE 4.3.0
